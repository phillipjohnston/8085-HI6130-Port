# IAR project at91sam3u-ek.ewp, settings and files
configuration BC_ONLY (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: at91sam3u4_flash.bin
  ILINK.IlinkOutputFile: at91sam3u-ek.out
configuration SMT_ONLY (ARM, debug)
  as the first configuration, except:
configuration RT_ONLY (ARM, debug)
  as the first configuration, except:
configuration IMT_ONLY (ARM, debug)
  as the first configuration, except:
configuration BC_SMT_RT (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT91SAM3U1 Atmel AT91SAM3U1
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: at91sam3u4
  ICCARM.PreInclude: C:\Users\Phillip\Dropbox\SeniorDesign\HoltICDemoKit\Projects\_Holt HI-6130-40 EBI Demo 2_0\613x_initialization.h
  ICCARM.CCIncludePath2: C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.5\arm\examples\Atmel\at91lib\boards\at91sam3u-ek; C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.5\arm\examples\Atmel\at91lib\peripherals\; C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.5\arm\examples\Atmel\external_libs\; C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.5\arm\examples\Atmel\at91lib\; C:\Users\Phillip\Dropbox\SeniorDesign\HoltICDemoKit\Projects\_Holt HI-6130-40 EBI Demo 2_0\
  ICCARM.CCOptLevel: 0
  AARM.ADefines: at91sam3u4
  AARM.AUserIncludes: as above
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RT_SMT (ARM, debug)
  as the first configuration, except:
configuration RT_IMT (ARM, debug)
  as the first configuration, except:
  group .
    $EW_DIR$/arm/examples/Atmel/: basic-usart-hw-handshaking-project
  group at91lib/boards/at91sam3u-ek
    $EW_DIR$/arm/examples/Atmel/at91lib/boards/at91sam3u-ek/: board.h board_cstartup_iar.c board_lowlevel.h board_memories.c board_memories.h exceptions.c exceptions.h
    ../: board_lowlevel.c
  group at91lib/boards/at91sam3u-ek/at91sam3u4
    $EW_DIR$/arm/examples/Atmel/at91lib/boards/at91sam3u-ek/at91sam3u4/: AT91SAM3U4.h chip.h flash.icf psram.icf sram.icf
  group at91lib/peripherals/dbgu
    $EW_DIR$/arm/examples/Atmel/at91lib/peripherals/dbgu/: dbgu.h
  group at91lib/peripherals/irq
    $EW_DIR$/arm/examples/Atmel/at91lib/peripherals/irq/: irq.h nvic.c
  group at91lib/peripherals/pio
    $EW_DIR$/arm/examples/Atmel/at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    $EW_DIR$/arm/examples/Atmel/at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/spi
    $EW_DIR$/arm/examples/Atmel/at91lib/peripherals/spi/: spi.c spi.h
  group at91lib/peripherals/tc
    $EW_DIR$/arm/examples/Atmel/at91lib/peripherals/tc/: tc.c tc.h
  group at91lib/peripherals/usart
    $EW_DIR$/arm/examples/Atmel/at91lib/peripherals/usart/: usart.c usart.h
  group at91lib/utility
    $EW_DIR$/arm/examples/Atmel/at91lib/utility/: assert.h trace.h
  group documentation
    $EW_DIR$/arm/examples/Atmel/: flashloaders.html
    $EW_DIR$/arm/examples/Atmel/documentation/: index.html
  group external_libs/cmsis
    $EW_DIR$/arm/examples/Atmel/external_libs/cmsis/: core_cm3.c core_cm3.h
  group Holt_HI-6130_40 EBI Demo/6130_EBI_BUS
    ../: board_6130.c board_6130.h device_6130.h
  group Holt_HI-6130_40 EBI Demo/BC
    ../: 613x_bc.c 613x_bc.h
  group Holt_HI-6130_40 EBI Demo/Holt_Common_Files
    ../: 613x_initialization.h 613x_regs.h board_613x.c board_613x.h console.c console.h main.c printf_usart.c
  group Holt_HI-6130_40 EBI Demo/MT
    ../: 613x_mt.c 613x_mt.h
  group Holt_HI-6130_40 EBI Demo/RT
    ../: 613x_rt.c 613x_rt.h
  group resources
    $EW_DIR$/arm/examples/Atmel/resources/iar/: at91sam3u-ek-flash.mac at91sam3u-ek-psram.mac at91sam3u-ek-sram.mac
