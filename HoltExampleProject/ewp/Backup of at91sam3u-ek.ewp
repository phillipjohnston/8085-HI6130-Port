# IAR project Backup of at91sam3u-ek.ewp, settings and files
configuration BC_ONLY (ARM, debug)
  General.OGChipSelectEditMenu: at91sam3u4 Atmel at91sam3u4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: at91sam3u4; flash; TRACE_LEVEL=4; BC_ena=1; RT2_ena=0; RT1_ena=0; SMT_ena=0; IMT_ena=0
  ICCARM.CCDiagSuppress: Pe826,Pe1375,Pe068
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam3u-ek
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: at91sam3u4; flash; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam3u-ek
  OBJCOPY.OOCOutputFile: at91sam3u4_flash.bin
  ILINK.IlinkOutputFile: at91sam3u4_flash.out
  ILINK.IlinkConfigDefines: define symbol HOST_BUS_INTERFACE = 1
  ILINK.IlinkIcfFile: ..\..\..\at91lib\boards\at91sam3u-ek\at91sam3u4\flash
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SMT_ONLY (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam3u4; flash; TRACE_LEVEL=4; BC_ena=0; RT2_ena=0; RT1_ena=0; SMT_ena=1; IMT_ena=0
configuration RT_ONLY (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam3u4; flash; TRACE_LEVEL=4; BC_ena=0; RT2_ena=1; RT1_ena=1; SMT_ena=0; IMT_ena=0
configuration IMT_ONLY (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam3u4; flash; TRACE_LEVEL=4; BC_ena=0; RT2_ena=0; RT1_ena=0; SMT_ena=0; IMT_ena=1
configuration BC_SMT_RT (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam3u4; flash; TRACE_LEVEL=4; BC_ena=1; RT2_ena=1; RT1_ena=1; SMT_ena=1; IMT_ena=0
configuration RT_SMT (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam3u4; flash; TRACE_LEVEL=4; BC_ena=0; RT2_ena=1; RT1_ena=1; SMT_ena=1; IMT_ena=0
configuration RT_IMT (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam3u4; flash; TRACE_LEVEL=4; BC_ena=0; RT2_ena=1; RT1_ena=1; SMT_ena=0; IMT_ena=1
  group .
    $EW_DIR$/arm/examples/Atmel/: basic-usart-hw-handshaking-project
  group at91lib/boards/at91sam3u-ek
    $EW_DIR$/arm/examples/Atmel/at91lib/boards/at91sam3u-ek/: board.h board_cstartup_iar.c board_lowlevel.h board_memories.c board_memories.h exceptions.c exceptions.h
    ../: board_lowlevel.c
  group at91lib/boards/at91sam3u-ek/at91sam3u4
    $EW_DIR$/arm/examples/Atmel/at91lib/boards/at91sam3u-ek/at91sam3u4/: AT91SAM3U4.h chip.h flash.icf psram.icf sram.icf
  group at91lib/peripherals/dbgu
    $EW_DIR$/arm/examples/Atmel/at91lib/peripherals/dbgu/: dbgu.h
  group at91lib/peripherals/irq
    $EW_DIR$/arm/examples/Atmel/at91lib/peripherals/irq/: irq.h nvic.c
  group at91lib/peripherals/pio
    $EW_DIR$/arm/examples/Atmel/at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pmc
    $EW_DIR$/arm/examples/Atmel/at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/spi
    $EW_DIR$/arm/examples/Atmel/at91lib/peripherals/spi/: spi.c spi.h
  group at91lib/peripherals/tc
    $EW_DIR$/arm/examples/Atmel/at91lib/peripherals/tc/: tc.c tc.h
  group at91lib/peripherals/usart
    $EW_DIR$/arm/examples/Atmel/at91lib/peripherals/usart/: usart.c usart.h
  group at91lib/utility
    $EW_DIR$/arm/examples/Atmel/at91lib/utility/: assert.h trace.h
  group documentation
    $EW_DIR$/arm/examples/Atmel/: flashloaders.html
    $EW_DIR$/arm/examples/Atmel/documentation/: index.html
  group external_libs/cmsis
    $EW_DIR$/arm/examples/Atmel/external_libs/cmsis/: core_cm3.c core_cm3.h
  group Holt_HI-6130_40 EBI Demo/6130_EBI_BUS
    ../: board_6130.c board_6130.h device_6130.h
  group Holt_HI-6130_40 EBI Demo/BC
    ../: 613x_bc.c 613x_bc.h
  group Holt_HI-6130_40 EBI Demo/Holt_Common_Files
    ../: 613x_initialization.h 613x_regs.h board_613x.c board_613x.h console.c console.h main.c printf_usart.c
  group Holt_HI-6130_40 EBI Demo/MT
    ../: 613x_mt.c 613x_mt.h
  group Holt_HI-6130_40 EBI Demo/RT
    ../: 613x_rt.c 613x_rt.h
  group resources
    $EW_DIR$/arm/examples/Atmel/resources/iar/: at91sam3u-ek-flash.mac at91sam3u-ek-psram.mac at91sam3u-ek-sram.mac
